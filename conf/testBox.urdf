Commit message: working on object dynamics with pinocchio

File: conf/testBox.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- removed link box
- added link base_link, mass 1; collision box size=.1 .2 .3; visual box size=.1 .2 .3
